# Keil uVision project RTT_Myproject.uvprojx, settings and files
target RTT_Myproject_GLZ (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTT_Myproject_GLZ +hex
  AfterMake: E:\Programfiles\Keil\ARM\ARMCC\bin\fromelf.exe  --bin -o ../OBJ/RTT_Myproject_GLZ.bin ../OBJ/RTT_Myproject_GLZ.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,ARM_MATH_CM4,DEBUG_ENABLE_SEMIHOST
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM;..\HARDWARE;..\HARDWARE\device_BME280;..\HARDWARE\device_usb_vcp;..\HARDWARE\device_usb_vcp\STM32_USB_Device_Library\Class\CDC\Inc;..\HARDWARE\device_usb_vcp\STM32_USB_Device_Library\Core\Inc;..\ZlGGUI
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f401xe.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
  group SYSTEM
    ../SYSTEM/: system.c systemglobal.c
  group GUI
    ../ZlGGUI/: ConvertColor.c font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C lcmdrv.c loadbit.c menu.c spline.c windows.c
  group HARDWARE
    ../HARDWARE/: device_usart.c device_gpio.c device_adc.c device_iic.c device_rtc.c device_usb.c device_spi.c device_flash.c device_oled.c device_key.c device_menu.c device_433.c device_crc.c device_atk_as608.c device_printf.c
    ../HARDWARE/device_BME280/: device_bme280.c
  group USBCDC
    ../HARDWARE/device_usb_vcp/: usbd_cdc_if.c usbd_conf.c usbd_desc.c
    ../HARDWARE/device_usb_vcp/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../HARDWARE/device_usb_vcp/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group README
    ../: readme.txt
software components: RTOS:kernel 2.1.2
